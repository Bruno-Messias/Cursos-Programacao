options:
  parameters:
    author: Bruno C. Messias
    generate_options: qt_gui
    id: Tutorial
    output_language: python
    title: Tutorial - GNURADIO
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: selector
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2
    label: Select Source
    label0: Sound Card
    label1: Test Signal
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: sigtype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0
    label0: Sine
    label1: Square
    num_opts: '2'
    option1: '103'
    type: int
    value: '101'
  states: {}
- name: uifreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    orient: Qt.Horizontal
    start: '10'
    step: '10'
    stop: '100000'
    value: '1000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: uifreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: sigtype
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,3
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
