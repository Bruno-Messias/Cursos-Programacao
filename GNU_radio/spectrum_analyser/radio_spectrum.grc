options:
  parameters:
    author: Bruno C. Messias
    copyright: '2020'
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: FM_Radio
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '87900000'
    step: '100000'
    stop: '108100000'
    value: '100300000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    bw0: '200000'
    freq0: tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
